# Keil uVision project IEC60730_ClassB.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: IEC60730_ClassB
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=$L@L.bin #L
  AfterMake: ./check_file.exe 128 20 "$L@L.bin"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: .\User;.\STM32F103C8T6\CMSIS\Core;.\STM32F103C8T6\CMSIS\Startup;.\STM32F103C8T6\CMSIS\System;.\STM32F103C8T6\STM32F10x_StdPeriph_Driver\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c
  group CMSIS\Core
    ./STM32F103C8T6/CMSIS/Core/: core_cm3.c core_cm3.h
  group CMSIS\Startup
    ./STM32F103C8T6/CMSIS/Startup/: startup_stm32f10x_md.s
  group CMSIS\System
    ./STM32F103C8T6/CMSIS/System/: stm32f10x.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c system_stm32f10x.h
  group STM32F10x_StdPeriph_Driver\Source
    ./STM32F103C8T6/STM32F10x_StdPeriph_Driver/Source/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
